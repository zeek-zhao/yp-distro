EXTRA_IMAGEDEPENDS += "cpp-hello-scancode"
IMAGE_INSTALL += "virtual/cpp-hello"